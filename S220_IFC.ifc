Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2020-05-05T12:10:20
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190507_1515(x64) - Exporter 17.0.517.0 - Alternate UI 17.15.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue May 05 12:10:20 2020 * Host: DESKTOP-KN3O7NT * Database: C:\Users\SARAHS~1\AppData\Local\Temp\{5752D9BE-177A-4311-A804-C2BD82973FF7}\ifc * Database version: 5507 * Database creation date: Tue May 05 12:10:15 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue May 05 12:10:16 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue May 05 12:10:16 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 0
LongName: Level 0; Elevation: 0 mm

# IfcBuildingElementProxy: Battery Pack Brushed Stainless Steel, Duten_SoapDpnsrs_S220:Battery Pack Brushed Stainless Steel:309783
In: Level 0
Type - PredefinedType: USERDEFINED; Classification: E2020200 Furniture & Accessories (Uniformat); Material: Duten_Plastic_Black, Duten_Metal_BrushedStainlessSteel
Pset_BuildingElementProxyCommon - Reference: n/a
Pset_ManufacturerTypeInformation - ModelReference: Battery Pack Brushed Stainless Steel; Manufacturer: Duten

# IfcBuildingElementProxy: Battery Pack Matte Black, Duten_SoapDpnsrs_S220:Battery Pack Matte Black:309934
In: Level 0
Type - PredefinedType: USERDEFINED; Classification: E2020200 Furniture & Accessories (Uniformat); Material: Duten_Plastic_Black, Duten_Metal_MatteBlack
Pset_BuildingElementProxyCommon - Reference: n/a
Pset_ManufacturerTypeInformation - ModelReference: Battery Pack Matte Black; Manufacturer: Duten

# IfcBuildingElementProxy: Battery Pack Polished Stainless Steel, Duten_SoapDpnsrs_S220:Battery Pack Polished Stainless Steel:309919
In: Level 0
Type - PredefinedType: USERDEFINED; Classification: E2020200 Furniture & Accessories (Uniformat); Material: Duten_Plastic_Black, Duten_Metal_Polished
Pset_BuildingElementProxyCommon - Reference: n/a
Pset_ManufacturerTypeInformation - ModelReference: Battery Pack Polished Stainless Steel; Manufacturer: Duten
